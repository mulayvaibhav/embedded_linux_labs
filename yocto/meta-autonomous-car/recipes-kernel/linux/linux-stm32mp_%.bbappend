FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-stm32mp257f-dk-enable-usart6.patch"
